# IAR project Backup of LoRaNode.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\..; ..\..\Driver; ..\..\Application\Include; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Driver\STM8L15x_StdPeriph_Driver\inc; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Driver\Include; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\ports; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\core; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\core\sys; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\core\dev; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\core\net; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\core\net\rime; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Contiki\core\net\mac; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\RF; ..\..\..\..\ShareCode\ContikiSTM8LSX1278\Application\Include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LoRaNode.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../../: main.c
  group Application
    ../../Application/Source/: Comm2Trm.c Monitor.c Network.c PwrManage.c SystSettings.c
    ../../../../ShareCode/ContikiSTM8LSX1278/Application/Source/: Dbg.c Util.c
  group Contiki/core/lib
    ../../../../ShareCode/ContikiSTM8LSX1278/Contiki/core/lib/: assert.c checkpoint.c crc16.c gcr.c ifft.c libconio.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c strncasecmp.c trickle-timer.c
  group Contiki/core/net
    ../../../../ShareCode/ContikiSTM8LSX1278/Contiki/core/net/: packetbuf.c
  group Contiki/core/net/rime
    ../../../../ShareCode/ContikiSTM8LSX1278/Contiki/core/net/rime/: rimeaddr.c
  group Contiki/core/sys
    ../../../../ShareCode/ContikiSTM8LSX1278/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group Contiki/ports
    ../../../../ShareCode/ContikiSTM8LSX1278/Contiki/ports/: clock.c hal.c rtimer-arch.c
  group Driver
    ../../../../ShareCode/ContikiSTM8LSX1278/Driver/Source/: Chip.c EEPROM.c RTC.c SHT7x.c SPI.c TempTimer.c Tim4UART.c Wdg.c
    ../../Driver/: CommPC.c DebugPort.c stm8l15x_it.c
  group Driver/STM8L15x_StdPeriph_Driver
    ../../../../ShareCode/ContikiSTM8LSX1278/Driver/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group RF
    ../../../../ShareCode/ContikiSTM8LSX1278/RF/: sx1278_ports.c sx1278_src.c
